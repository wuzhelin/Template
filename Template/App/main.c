/* 头文件 ----------------------------------------------------------------*/
#include <main.c>
/*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>
* 文件名  ： main.c
* 作者    ： wuzhelin
* 版本    ： V1.0.0
* 时间    ： 2019/9/16
* 简要    ： 主函数所在文件的入口  
*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>*/

/* 函数 ------------------------------------------------------------------*/
/*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>
* 文件名  ： <ioCC2530.h>
* 作者    ： wuzhelin
* 版本    ： V1.0.0
* 时间    ： 2019/9/16
* 简要    ： 定义了ioCC2530各类寄存器  
*>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>>*/

#include <ioCC2530.h>  


#define LED1 P1_0     // P1_0定义为P1.0
#define LED2 P1_1     // P1_1定义为P1.1


unsigned int temp = 0;
/*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
* 函数名：delay
* 参数：unsigned int time
* 返回：无
* 描述：函数说明
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
//1ms精确定时
void delay (unsigned int time)
{   
    unsigned int i = 0;
    unsigned int j;
for(i = 0; i < time; i++)
    {
          for(j = 0; j < 475; j++)
      {   
          asm("NOP");   
          asm("NOP");
          asm("NOP");
       } 
    } 
}
/*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
* 函数名：main
* 参数：void
* 返回：void
* 描述：主函数
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
void main(void)
{
    P1SEL &= ~0x03;
    P1DIR |= 0x03 ;   
while(1)
    {
        LED1 = 1;    
        LED2 = 0;   
        delay(1000);
        LED1 = 0;    
        LED2 = 1;     
        delay(1000);
     }

}
